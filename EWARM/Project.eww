<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Linear_Actuator_IRC.ewp</path>
  </project>
  <batchBuild />
</workspace>
